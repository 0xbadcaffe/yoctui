FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI:append = " file://yoctui-live-debug.cfg"
